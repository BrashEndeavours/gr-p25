<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx_filter_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>rx_filter_test</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>55</value></param>
<param><key>label</key><value>Delay</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>200</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>delay2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Delay2</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>4800</value></param>
</block>
<block>
<key>analog_random_uniform_source_x</key>
<param><key>id</key><value>analog_random_uniform_source_x_0</value></param>
<param><key>maximum</key><value>4</value></param>
<param><key>minimum</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>int(delay)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>int(delay2)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>sample_rate</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>10</value></param>
<param><key>taps</key><value>(1,)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>p25_dibit_mapper_bf</key>
<param><key>id</key><value>p25_dibit_mapper_bf_0</value></param>
<param><key>dibit_map</key><value>[1, 3, -1, -3]</value></param>
<param><key>filename</key><value></value></param>
<param><key>log_level</key><value>logging.NOTSET</value></param>
</block>
<block>
<key>p25_rx_nyquist_filter_ff</key>
<param><key>id</key><value>p25_rx_nyquist_filter_ff_0</value></param>
<param><key>span</key><value>11</value></param>
<param><key>filter_gain</key><value>1.0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>sample_rate</key><value>48000</value></param>
<param><key>symbol_rate</key><value>4800</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>p25_rx_shaping_filter_ff</key>
<param><key>id</key><value>p25_rx_shaping_filter_ff_0</value></param>
<param><key>span</key><value>11</value></param>
<param><key>filter_gain</key><value>1.0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>sample_rate</key><value>48000</value></param>
<param><key>symbol_rate</key><value>4800</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>p25_tx_nyquist_filter_ff</key>
<param><key>id</key><value>p25_tx_nyquist_filter_ff_0</value></param>
<param><key>span</key><value>11</value></param>
<param><key>filter_gain</key><value>1.0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>sample_rate</key><value>48000</value></param>
<param><key>symbol_rate</key><value>4800</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>p25_tx_shaping_filter_ff</key>
<param><key>id</key><value>p25_tx_shaping_filter_ff_0</value></param>
<param><key>span</key><value>11</value></param>
<param><key>filter_gain</key><value>1.0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>sample_rate</key><value>48000</value></param>
<param><key>symbol_rate</key><value>4800</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Post RX Shaping</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Post Nyquist</value></param>
<param><key>name</key><value>Nyquist Filter Test</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>512</value></param>
<param><key>srate</key><value>48000</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.5</value></param>
<param><key>ylabel</key><value>Level</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>-4</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>input</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>input</value></param>
</block>
<connection><source_block_id>analog_random_uniform_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>p25_rx_shaping_filter_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>p25_dibit_mapper_bf_0</source_block_id><sink_block_id>p25_tx_nyquist_filter_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>p25_rx_nyquist_filter_ff_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>p25_rx_shaping_filter_ff_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>p25_rx_shaping_filter_ff_0</source_block_id><sink_block_id>p25_rx_nyquist_filter_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>p25_tx_nyquist_filter_ff_0</source_block_id><sink_block_id>p25_tx_shaping_filter_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>p25_tx_shaping_filter_ff_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>p25_dibit_mapper_bf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

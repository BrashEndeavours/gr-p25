<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>p25_demodulator_chain_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>p25_demodulator_chain_test</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>adjustment</value></param>
<param><key>value</key><value>0.051533333 * 48000 / 4800</value></param>
<param><key>gui_hint</key><value>1,0,1,5</value></param>
<param><key>label</key><value>Sensitivity</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>dibit_delay</value></param>
<param><key>value</key><value>11</value></param>
<param><key>gui_hint</key><value>tab1@1</value></param>
<param><key>label</key><value>Dibit Delay</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>200</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>dibits_delay</value></param>
<param><key>value</key><value>17</value></param>
<param><key>gui_hint</key><value>tab1@3</value></param>
<param><key>label</key><value>Dibits Delay</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>200</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>input_chooser</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label0</key><value>Test Symbol stream [3,3,-3,-3]</value></param>
<param><key>label1</key><value>Stochastic Stream</value></param>
<param><key>label</key><value>Input Selection</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>wave_delay</value></param>
<param><key>value</key><value>5</value></param>
<param><key>gui_hint</key><value>tab1@3</value></param>
<param><key>label</key><value>Waveform Delay</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>200</value></param>
</block>
<block>
<key>analog_random_uniform_source_x</key>
<param><key>id</key><value>analog_random_uniform_source_x_0</value></param>
<param><key>maximum</key><value>4</value></param>
<param><key>minimum</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>int(dibit_delay)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0</value></param>
<param><key>delay</key><value>int(dibits_delay)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0_0</value></param>
<param><key>delay</key><value>int(wave_delay)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0_0_1</value></param>
<param><key>delay</key><value>int(dibits_delay)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>1 if input_chooser == 0 else 0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>1 if input_chooser == 1 else 0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>240000</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>(1,1,3,3)</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>c4fm_f_stream</value></param>
<param><key>stream_id</key><value>f_stream</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>c4fm_f_stream_0</value></param>
<param><key>stream_id</key><value>rx_stream</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>dibits</value></param>
<param><key>stream_id</key><value>dibits</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>dibits_0</value></param>
<param><key>stream_id</key><value>dibits</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>dibits_src</value></param>
<param><key>stream_id</key><value>dibits</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>dibits_src_0</value></param>
<param><key>stream_id</key><value>dibits</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>f_stream_src</value></param>
<param><key>stream_id</key><value>f_stream</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>taps</key><value>(0,0,0,0,0,1,)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import gnuradio.filter as filter</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>10</value></param>
<param><key>taps</key><value>(1,)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0</value></param>
<param><key>interp</key><value>10</value></param>
<param><key>taps</key><value>(1,)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0_0</value></param>
<param><key>interp</key><value>10</value></param>
<param><key>taps</key><value>(1,)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0_0_0</value></param>
<param><key>interp</key><value>10</value></param>
<param><key>taps</key><value>(1,)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0_1</value></param>
<param><key>interp</key><value>10</value></param>
<param><key>taps</key><value>(1,)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Adjust the Sensitivity to obtain a peak of 2827 Hz with the setup signal</value></param>
</block>
<block>
<key>p25_c4fm_modulator_bf</key>
<param><key>id</key><value>p25_c4fm_modulator_bf_0</value></param>
<param><key>dibit_map</key><value>[1.0/3.0, 1.0, -(1.0/3.0), -1.0]</value></param>
<param><key>filter_gain</key><value>1</value></param>
<param><key>span</key><value>11</value></param>
<param><key>log</key><value>False</value></param>
<param><key>sample_rate</key><value>48000</value></param>
<param><key>symbol_rate</key><value>4800</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>p25_dibit_mapper_bf</key>
<param><key>id</key><value>p25_dibit_mapper_bf_0</value></param>
<param><key>dibit_map</key><value>[1, 3, -1, -3]</value></param>
<param><key>filename</key><value></value></param>
<param><key>log_level</key><value>logging.NOTSET</value></param>
</block>
<block>
<key>p25_freq_demod_cf</key>
<param><key>id</key><value>p25_freq_demod_cf_0</value></param>
<param><key>gain_adjust</key><value>1.0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>max_amplitude</key><value>4.38895</value></param>
<param><key>max_deviation</key><value>2827</value></param>
<param><key>sample_rate</key><value>48000</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>p25_freq_mod_fc</key>
<param><key>id</key><value>p25_freq_mod_fc_0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>max_amplitude</key><value>4.38895</value></param>
<param><key>max_deviation</key><value>2827</value></param>
<param><key>sample_rate</key><value>48000</value></param>
<param><key>sensitivity_adjust</key><value>1</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>p25_rx_shaping_filter_ff</key>
<param><key>id</key><value>p25_rx_shaping_filter_ff_0</value></param>
<param><key>span</key><value>11</value></param>
<param><key>filter_gain</key><value>3</value></param>
<param><key>log</key><value>False</value></param>
<param><key>sample_rate</key><value>48000</value></param>
<param><key>symbol_rate</key><value>4800</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>pam_pam_slicer_fb</key>
<param><key>id</key><value>pam_pam_slicer_fb_0</value></param>
<param><key>dibits</key><value>[-3, -1, 1, 3]</value></param>
<param><key>slice_levels</key><value>[-2, 0, 2]</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>tab1@0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Original Byte</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Converted Dibit</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>128</value></param>
<param><key>srate</key><value>48000</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.0001</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>-4</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>tab1@1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Original Byte</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>C4FM Waveform</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>256</value></param>
<param><key>srate</key><value>48000</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.0001</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>-4</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0_0</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>tab1@3</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Transmitted Dibit</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Shaped Waveform</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Recovered Dibit</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>48000</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.0001</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>-4</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0_0_0</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>gui_hint</key><value>tab1@4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Original Dibit</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Recovered Dibit</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Sliced Dibit</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>48000</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.0001</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>-4</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab1</value></param>
<param><key>label0</key><value>Byte to Dibit Mapping</value></param>
<param><key>label1</key><value>Dibit to C4FM Mapping</value></param>
<param><key>label2</key><value>Waveform Recovery</value></param>
<param><key>label3</key><value>Non-Sliced Dibit Recovery</value></param>
<param><key>label4</key><value>Sliced Dibit Recovery</value></param>
<param><key>num_tabs</key><value>5</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>input</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>C4FM Stream</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>Sliced Output</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0_0</value></param>
<param><key>stream_id</key><value>Non-Sliced Output</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_1</value></param>
<param><key>stream_id</key><value>Symbol Input</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>input</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>C4FM Stream</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_1</value></param>
<param><key>stream_id</key><value>Non-Sliced Output</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_1_0</value></param>
<param><key>stream_id</key><value>Sliced Output</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>stream_id</key><value>input</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1_0</value></param>
<param><key>stream_id</key><value>input</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_2_0</value></param>
<param><key>stream_id</key><value>rx_stream</value></param>
</block>
<connection><source_block_id>analog_random_uniform_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0_0_1</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>virtual_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dibits_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dibits_src</source_block_id><sink_block_id>blocks_delay_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dibits_src_0</source_block_id><sink_block_id>blocks_delay_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>f_stream_src</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>pam_pam_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>virtual_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_1</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0_1</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>p25_c4fm_modulator_bf_0</source_block_id><sink_block_id>c4fm_f_stream</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>p25_c4fm_modulator_bf_0</source_block_id><sink_block_id>p25_freq_mod_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>p25_dibit_mapper_bf_0</source_block_id><sink_block_id>dibits</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>p25_dibit_mapper_bf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>p25_freq_demod_cf_0</source_block_id><sink_block_id>p25_rx_shaping_filter_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>p25_freq_mod_fc_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>p25_rx_shaping_filter_ff_0</source_block_id><sink_block_id>c4fm_f_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>p25_rx_shaping_filter_ff_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pam_pam_slicer_fb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>p25_c4fm_modulator_bf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>p25_freq_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_1</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_1_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>p25_dibit_mapper_bf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1_0</source_block_id><sink_block_id>blocks_char_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2_0</source_block_id><sink_block_id>blocks_delay_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>Volume</value></param>
<param><key>value</key><value>0.00003</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.00001</value></param>
<param><key>stop</key><value>0.001</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>adjustment</value></param>
<param><key>value</key><value>0.051533333 * 48000 / 4800</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Sensitivity</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>input_chooser</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label0</key><value>Test Symbol stream [3,3,-3,-3]</value></param>
<param><key>label1</key><value>Stochastic Stream</value></param>
<param><key>label</key><value>Input Selection</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>sample_rate/(2*math.pi)</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0_0</value></param>
<param><key>gain</key><value>sample_rate/(2*math.pi)</value></param>
</block>
<block>
<key>analog_random_uniform_source_x</key>
<param><key>id</key><value>analog_random_uniform_source_x_0</value></param>
<param><key>maximum</key><value>4</value></param>
<param><key>minimum</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>1 if input_chooser == 0 else 0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>1 if input_chooser == 1 else 0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>sample_rate * 10</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>(1,1,3,3)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import gnuradio.filter as filter</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Adjust the Sensitivity to obtain a peak of 2827 Hz with the setup signal</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>sample_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>affinity</key><value>3</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@1</value></param>
<param><key>label1</key><value>C4FM Block Chain Input</value></param>
<param><key>label2</key><value>C4FM Modulator Input</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>tabs@0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>C4FM Block Chain Input</value></param>
<param><key>marker1</key><value>2</value></param>
<param><key>style1</key><value>0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>C4FM Modulator Input</value></param>
<param><key>marker2</key><value>3</value></param>
<param><key>style2</key><value>0</value></param>
<param><key>name</key><value>Nyquist Filter Test</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>500</value></param>
<param><key>srate</key><value>sample_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>ylabel</key><value>Level</value></param>
<param><key>ymax</key><value>4000</value></param>
<param><key>ymin</key><value>-4000</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>sample_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>tabs@2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tabs</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label0</key><value>Time Comparison</value></param>
<param><key>label1</key><value>Freq Comparison</value></param>
<param><key>label2</key><value>Waterfall of C4FM Modulation</value></param>
<param><key>num_tabs</key><value>3</value></param>
</block>
<block>
<key>thesis_p25_c4fm_modulator_bf</key>
<param><key>id</key><value>thesis_p25_c4fm_modulator_bf_0</value></param>
<param><key>dibit_map</key><value>[1, 3, -1, -3]</value></param>
<param><key>filter_gain</key><value>1.0</value></param>
<param><key>span</key><value>11</value></param>
<param><key>log</key><value>False</value></param>
<param><key>sample_rate</key><value>48000</value></param>
<param><key>symbol_rate</key><value>4800</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>thesis_p25_dibit_mapper_bf</key>
<param><key>id</key><value>thesis_p25_dibit_mapper_bf_0</value></param>
<param><key>dibit_map</key><value>[1, 3, -1, -3]</value></param>
<param><key>log</key><value>False</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>thesis_p25_freq_mod_fc</key>
<param><key>id</key><value>thesis_p25_freq_mod_fc_0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>max_deviation</key><value>12500</value></param>
<param><key>sample_rate</key><value>48000</value></param>
<param><key>sensitivity_adjust</key><value>adjustment</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>thesis_p25_freq_mod_fc</key>
<param><key>id</key><value>thesis_p25_freq_mod_fc_0_0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>max_deviation</key><value>12500</value></param>
<param><key>sample_rate</key><value>48000</value></param>
<param><key>sensitivity_adjust</key><value>adjustment</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>thesis_p25_tx_nyquist_filter_ff</key>
<param><key>id</key><value>thesis_p25_tx_nyquist_filter_ff_0</value></param>
<param><key>span</key><value>11</value></param>
<param><key>filter_gain</key><value>1.0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>sample_rate</key><value>sample_rate</value></param>
<param><key>symbol_rate</key><value>4800</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>thesis_p25_tx_shaping_filter_ff</key>
<param><key>id</key><value>thesis_p25_tx_shaping_filter_ff_0</value></param>
<param><key>span</key><value>11</value></param>
<param><key>filter_gain</key><value>1.0</value></param>
<param><key>log</key><value>False</value></param>
<param><key>sample_rate</key><value>sample_rate</value></param>
<param><key>symbol_rate</key><value>4800</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>input</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>input</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_random_uniform_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>thesis_p25_c4fm_modulator_bf_0</source_block_id><sink_block_id>thesis_p25_freq_mod_fc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>thesis_p25_dibit_mapper_bf_0</source_block_id><sink_block_id>thesis_p25_tx_nyquist_filter_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>thesis_p25_freq_mod_fc_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>thesis_p25_freq_mod_fc_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>thesis_p25_freq_mod_fc_0_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>thesis_p25_freq_mod_fc_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>thesis_p25_freq_mod_fc_0_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>thesis_p25_tx_nyquist_filter_ff_0</source_block_id><sink_block_id>thesis_p25_tx_shaping_filter_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>thesis_p25_tx_shaping_filter_ff_0</source_block_id><sink_block_id>thesis_p25_freq_mod_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>thesis_p25_c4fm_modulator_bf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>thesis_p25_dibit_mapper_bf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sample_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>sample_rate</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>[0, 1, 2, 3]</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Dibit Input</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>style1</key><value>0</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Dibit Mapping</value></param>
<param><key>marker2</key><value>2</value></param>
<param><key>style2</key><value>0</value></param>
<param><key>name</key><value>Dibit Mapping Test</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>32</value></param>
<param><key>srate</key><value>sample_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>update_time</key><value>0.5</value></param>
<param><key>ylabel</key><value>Dibit Value</value></param>
<param><key>ymax</key><value>4</value></param>
<param><key>ymin</key><value>-4</value></param>
</block>
<block>
<key>thesis_p25_dibit_mapper_bf</key>
<param><key>id</key><value>thesis_p25_dibit_mapper_bf_0</value></param>
<param><key>dibit_map</key><value>[1,3,-1,-3]</value></param>
<param><key>log</key><value>False</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>thesis_p25_dibit_mapper_bf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>thesis_p25_dibit_mapper_bf_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
